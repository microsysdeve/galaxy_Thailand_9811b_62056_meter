# IAR project V9401.ewp, settings and files
configuration Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\_generic\plain.i51
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: Inc; IAR_V9401\LigerLib_Lv1_1.8\Inc; $TOOLKIT_DIR$\INC\LIB\
  ICC8051.CCStdIncludePath: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  XLINK.XclFile: xcl\lnk51ew.xcl
configuration Release (8051)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\
  General.RTConfigPath: xxx.h
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: cstartup.s51
  group LigerLib_Lv1_1.8
    LigerLib_Lv1_1.8/Buttom/: Alt_50_60Hz.c Alt_BatDisc.c DeepSleep.c InitAnalog.c InitMeter.c LigReg.c OpenPDT.c pmRead.c pmWrite.c Read_50_60Hz.c ReadMeterPara.c SetADC.c SetCrystal.c SetLCDVolt.c SetLDO33.c SetLDOVolt.c SetMChannel.c SetMeterCfg.c SetPLL.c Sleep.c
  group User
    Code/: delay.c delay.h Func.c Func.h main.c
  group xcl
    xcl/: lnk51ew.xcl
