# IAR project V9811Test.ewp, settings and files
configuration Debug (8051, debug)
  General.OGChipSelectMenu: plain Generic plain
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: INC\; $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: xcl\lnk51ew.xcl
configuration Release (8051)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  General.OGChipSelectMenu: 8052 Generic 8052
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: workaround.s51
  group Settings
    ./: cstartup.s51
    xcl/: lnk51ew.xcl
  group User
    code/: delay.c fun0.c fun1.c fun2.c main.c
