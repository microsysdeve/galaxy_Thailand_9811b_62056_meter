# IAR project Backup of D113.ewp, settings and files
configuration Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\_generic\plain.i51
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: Inc
  ICC8051.CCStdIncludePath: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICC8051.CCOptLevel: 2
  ICC8051.CCOptStrategy: 0
  XLINK.XclFile: lnk51ew.xcl
configuration Release (8051)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\
  General.RTConfigPath: xxx.h
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group (top)
    Src/: Api.c BEBottom.C ComApplication.C ComBottom.C ComCoretab.c cstartup.s51 Dataproc.c DataProtect.c DLT_645_2007.c Energy.c EnergyBottom.c InitPara.c Key.c KeyProc.c LcdBottom.c Lcdmiddle.c Lcdshow.c main.c McuDrive.c Powmanger.c Prcfrm.c Ptl_1107.c System.c Timeproc.c Uart2.c Uart4.c
