# IAR project Backup of D105R.ewp, settings and files
configuration Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\_generic\plain.i51
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: Inc
  ICC8051.CCStdIncludePath: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICC8051.CCOptLevel: 2
  ICC8051.CCOptStrategy: 0
  XLINK.XclFile: lnk51ew.xcl
configuration Release (8051)
  as the first configuration, except:
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 2
  group (top)
    Src/: Api.c BEBottom.C CmpCode.c ComApplication.C ComBottom.C ComCoretab.c cstartup.s51 Dataproc.c DataProtect.c DLT_645_2007.c Energy.c EnergyBottom.c Event.c FunCfg.c iar_banked_code_support.s51 InitPara.c Key.c LcdBottom.c Lcdmiddle.c Lcdshow.c LoadCurve.c main.c McuDrive.c Multariff.c Powmanger.c Prcfrm.c PrologFee.c RtcCpt.c System.c Timeproc.c Uart1.c Uart2.c Uart4.c Version.c
