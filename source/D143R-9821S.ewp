# IAR project D143R-9821S.ewp, settings and files
configuration Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\_generic\plain.i51
  ICC8051.CCDefines: _METER_FAR_; _DEBUG_; _ComUSE645_
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: Inc; ..\epson_rm8025fa\meter_m11\inc; ..\epson_rm8025fa\meter_m11\src
  ICC8051.CCOptLevel: 2
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: lnk51ew.xcl
configuration release (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: _METER_FAR_; _DEBUG_
configuration 62056 (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: _METER_FAR_; _DEBUG_
  group (top)
    Src/: adcfun.c Api.c ComApplication.C ComBottom.C cstartup.s51 Dataproc.c Demand.c Energy.c EnergyBottom.c FunCfg.c iar_banked_code_support.s51 InitPara.c LcdBottom.c main.c mainint_protect.c McuDrive.c Powmanger.c Prcfrm.c Ptl_1107.c pxv9811b.c RtcCpt.c System.c TamperProc.c Timeproc.c Timer0Capture.c Uart2.c Uart4.c uartiobase.c Version.c workaround.s51
    ../epson_rm8025fa/meter_m11/src/: bit_edge.c bit_edge.h dfinit.c Disp.c disp_format_lcd10329.c disp_format_lcd10329.h Drv_DispKey.c Drv_RTCSPK.c eeprom.c GC_Use.c globlvar.c indata_oper.c InOut.c mainapp.c Meter.c PubData.c public.c pwroffidsp.c safedate.c streamio.c TRx.c
    ./: lnk51ew.xcl
