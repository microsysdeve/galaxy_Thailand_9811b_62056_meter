<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\D143R-9821S.ewp</path>
  </project>
  <batchBuild/>
</workspace>


