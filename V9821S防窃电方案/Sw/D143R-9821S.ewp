# IAR project D143R-9821S.ewp, settings and files
configuration Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\_generic\plain.i51
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: Inc
  ICC8051.CCOptLevel: 2
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: lnk51ew.xcl
configuration Release (8051)
  as the first configuration, except:
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 2
  group (top)
    Src/: ADKfunc.c Api.c BEBottom.C ComApplication.C ComBottom.C ComCoretab.c cstartup.s51 Dataproc.c DataProtect.c Demand.c DLT_645_2007.c Energy.c EnergyBottom.c FunCfg.c InitPara.c Key.c LcdBottom.c Lcdmiddle.c Lcdshow.c main.c McuDrive.c Powmanger.c Prcfrm.c System.c TamperProc.c Timeproc.c Uart2.c Uart4.c Version.c workaround.s51
